FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"

# The file in meta-tegra applies only to jetson-tx2, but we are using e.g. "rudi" as machine,
# so we need to copy flashvars to our custom machine directory.

